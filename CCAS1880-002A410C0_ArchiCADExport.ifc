Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-06-09T10:36:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 09 10:36:41 2021 * Host: ws-118 * Database: C:\Users\RYAN~1.LAS\AppData\Local\Temp\{6B06BA8A-59E9-4DD5-9AEC-30547A7E350A}\ifc * Database version: 5507 * Database creation date: Wed Jun 09 10:36:41 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 09 10:36:41 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 09 10:36:41 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Signature One-Piece Toilet, AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0):Signature One-Piece Toilet:4701
In: Level 1
Classification: C1030200 (Uniformat); Material: Plastic - White, Chrome, Porcelain - White
Pset_ManufacturerTypeInformation - ModelReference: Signature One-Piece Toilet; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Signature One-Piece Toilet
Constraints - Elevation: 0 mm; WasteOffset: 305 mm
Construction - ToiletBowlHole: yes; ToiletLidTop: no; WasteOffset305mm: yes; WasteOffset400mm: no
Dimensions - Area: 0.814523 m2; Volume: 0.12007 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary,Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0): Signature One-Piece Toilet; Family and Type: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0): Signature One-Piece Toilet; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0): Signature One-Piece Toilet; Type Id: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0): Signature One-Piece Toilet; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: 3.5/5 litre per flush; InstallationType: Floor Standing; ProductCategory: Fixtures & Vanities (10); ProductGroup: WC One Piece (01); ProductWeight: 46 kg; StyleSegment: Modern; SubCategory: Chinaware/Ceramics (WC) (11)
Identity Data(Type) - Assembly Code: C1030200; Description: Signature One-Piece Toilet; Keynote: N13; Manufacturer: American Standard; Model: Signature One-Piece Toilet; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CCAS1880-002A410C0; Type Name: Signature One-Piece Toilet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ccas1880-002a410c0/document/object-user-guide; BIMObjectName: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0); NBSDescription: WC pans; NBSNote: n/a; NBSObjectName: American Standard - WC pans; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White Heat II; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ccas1880-002a410c0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ccas1880-002a410c0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ccas1880-002a410c0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ccas1880-002a410c0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ccas1880-002a410c0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_WCOnePiece_Signature_(CCAS1880-002A410C0); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: Vitreous China; ModelNumber: CCAS1880-002A410C0; ModelReference: Signature One-Piece Toilet; ProductionYear: 2021; ReferencedStandard: GB/T 6952-2015; ReplacementCost: n/a; Shape: n/a; Size: 727*384*650 mm; TypeName: Signature One-Piece Toilet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
